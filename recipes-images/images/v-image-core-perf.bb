inherit v-core-image

IMAGE_INSTALL:append = " \
    packagegroup-v-core-boot \
    packagegroup-v-core-perf \
    "