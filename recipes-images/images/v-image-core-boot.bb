inherit v-core-image

IMAGE_INSTALL:append = " \
    packagegroup-v-core-boot \
    "